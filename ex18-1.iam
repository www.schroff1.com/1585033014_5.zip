# Autodesk Inventor assembly: ex18-1
## iProperties
Created: 2006-04
Part Number: ex18-1
Document SubType Name: Assembly
Designer: E. MOSS
Author: E. MOSS
