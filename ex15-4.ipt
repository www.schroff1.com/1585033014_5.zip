# Autodesk Inventor part: ex15-4
## iProperties
Created: 2006-04
Part Number: ex15-4
Document SubType Name: Modeling
Designer: E. MOSS
Author: E. MOSS
