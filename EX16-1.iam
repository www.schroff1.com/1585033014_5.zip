# Autodesk Inventor assembly: EX16-1
## iProperties
Created: 2006-04
Part Number: EX16-1
Document SubType Name: Assembly
Designer: E. MOSS
Author: E. MOSS
