# Autodesk Inventor assembly: ex17-7
## iProperties
Created: 2006-04
Part Number: ex17-7
Document SubType Name: Assembly
Designer: E. MOSS
Author: E. MOSS
