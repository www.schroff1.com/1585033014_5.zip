# Autodesk Inventor assembly: ex20-6
## iProperties
Created: 2006-04
Part Number: ex20-6
Document SubType Name: Assembly
Designer: E. MOSS
Author: E. MOSS
