# Autodesk Inventor assembly: ex17-8
## iProperties
Created: 2006-04
Part Number: ex17-8
Document SubType Name: Assembly
Designer: E. MOSS
Author: E. MOSS
