# Autodesk Inventor assembly: ex20-8
## iProperties
Created: 2006-04
Part Number: ex20-8
Document SubType Name: Assembly
Designer: E. MOSS
Author: E. MOSS
