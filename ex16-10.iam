# Autodesk Inventor assembly: ex16-10
## iProperties
Created: 2006-04
Part Number: ex16-10
Document SubType Name: Assembly
Designer: E. MOSS
Author: E. MOSS
