# Autodesk Inventor assembly: EX16-8
## iProperties
Created: 2006-04
Part Number: EX16-8
Document SubType Name: Assembly
Designer: E. MOSS
Author: E. MOSS
